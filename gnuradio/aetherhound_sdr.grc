options:
  parameters:
    author: AetherHound Defensive SIGINT Team
    copyright: Infotact Solutions
    description: Air-Gapped Covert Channel RF and Acoustic DSP Filter & Spectrogram Pipeline
    generate_options: qt_gui
    id: aetherhound_sdr
    output_language: python
    run_command: '{python} : {filename}'
    title: AetherHound SDR & Acoustic DSP Flowgraph
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: 'Sample rate: 48 kHz (audio) or 2.4 MHz (RTL-SDR)'
    value: '48000'
  states: {}
- name: fft_size
  id: variable
  parameters:
    comment: FFT window length
    value: '1024'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    comment: Ultrasonic Microphone or Line In
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    comment: Filter out standard 50/60Hz AC mains and 120Hz rectifier hum
    decim: '1'
    gain: '1'
    high_cutoff_freq: samp_rate / 2 - 500
    low_cutoff_freq: '300'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: Frame batching
    num_items: fft_size
    type: float
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    comment: Windowed Fast Fourier Transform
    fft_size: fft_size
    forward: 'True'
    shift: 'False'
    type: float
    window: window.blackmanharris(fft_size)
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Calculate Power Spectrum
    vlen: fft_size
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    comment: Convert to logarithmic dB scale
    k: '0'
    n: '10'
    vlen: fft_size
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    comment: Stream live spectrogram vectors to AetherHound ML Engine
    destination_ip: 127.0.0.1
    destination_port: '9090'
    header: None
    payloadsize: 1024 * 4
    send_eof: 'False'
    type: byte
  states: {}

connections:
- [audio_source_0, '0', band_pass_filter_0, '0']
- [band_pass_filter_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', network_udp_sink_0, '0']

metadata:
  file_format: 1
